## general/package/testhello/Config.in
```kconfig
config BR2_PACKAGE_TESTHELLO
	bool "testhello"
	help
	  Test

	  https://github.com/dhrebeniuk/testhello
```
